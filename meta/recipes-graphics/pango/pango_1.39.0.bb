require pango.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

GNOME_COMPRESS_TYPE="xz"

#SRC_URI += "file://run-ptest \
#            file://multilib-fix-clean.patch \
#"

SRC_URI[archive.md5sum] = "e4173191fd7075614b88889509160f7e"
SRC_URI[archive.sha256sum] = "13072ad9e49372d6d7ba7bb3b9b025faef04de3552b745e92d7880eb15d6ee7e"
