require clutter-1.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=4fbd65380cdd255951079008b364516c"

SRC_URI[archive.md5sum] = "8f1349bdb214d97b922b3b834ab0208c"
SRC_URI[archive.sha256sum] = "55f8816cd3556831a259fd437e3a23774a29e914791575d4bc98fbc03fa02ee9"
